VERSION 5.8 ;
MACRO DFFNSRX1
  CLASS CORE ;
  SITE CoreSite ;
  SIZE 1.0 BY 2.0 ;
  PIN Q
    DIRECTION OUTPUT ;
  END Q
  PIN QN
    DIRECTION OUTPUT ;
  END QN
  PIN CKN
    DIRECTION INPUT ;
  END CKN
  PIN D
    DIRECTION INPUT ;
  END D
  PIN SN
    DIRECTION INPUT ;
  END SN
  PIN RN
    DIRECTION INPUT ;
  END RN
  PIN VDD
    DIRECTION INOUT ;
  END VDD
  PIN VSS
    DIRECTION INOUT ;
  END VSS
END DFFNSRX1
END LIBRARY
